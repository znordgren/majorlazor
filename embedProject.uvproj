# Keil uVision project embedProject.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC1768 NXP
  cpu: IROM(0x00000000,0x80000) IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: embedProject
  c flags: Optim=1 wLevel=2
  c include: C:\Keil_v5\ARM\Pack\Keil\LPC1700_DFP\2.3.0\Device\Include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Group 1
    ./files/: AsciiLib.c GLCD.c GLCD_LPC1700.c LED.c main.c system_LPC17xx.c uart.c AsciiLib.h font.h Font_24x16.h GLCD.h LED.h type.h uart.h startup_LPC17xx.s player.c player.h game.c game.h

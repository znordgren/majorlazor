# Keil uVision project LandTiger.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC1768 NXP
  cpu: IROM(0x00000000,0x80000) IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LandTiger
  c flags: Optim=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Group 1
    ../: GLCD.h GLCD_LPC1700.c main.c Serial.c Serial.h startup_LPC17xx.s system_LPC17xx.c AsciiLib.c AsciiLib.h Font_24x16.h uart.c uart.h type.h
